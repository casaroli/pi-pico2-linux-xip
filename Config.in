## Config.in
```kconfig
config BR2_PACKAGE_HELLO
	bool "hello"
	help
	  Minimal external build hello.

	  http://example.com/
```
